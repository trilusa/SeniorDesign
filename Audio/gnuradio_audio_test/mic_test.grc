options:
  parameters:
    generate_options: qt_gui
    id: mic_test
    output_language: python
    title: mic test
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: A
    start: '0'
    step: '.1'
    stop: '10'
    value: '1'
  states: {state: disabled}
- name: f
  id: variable_qtgui_range
  parameters:
    label: f
    start: '1'
    step: '10'
    stop: 10e3
    value: '1000'
  states: {state: disabled}
- name: high_cutoff
  id: variable
  parameters:
    value: '20000'
  states: {state: disabled}
- name: high_cutoff
  id: variable_qtgui_range
  parameters:
    label: A
    start: '200'
    step: '100'
    stop: '20000'
    value: '20000'
  states: {}
- name: low_cutoff
  id: variable_qtgui_range
  parameters:
    label: A
    start: '200'
    step: '100'
    stop: '20000'
    value: '200'
  states: {}
- name: low_cutoff
  id: variable
  parameters:
    value: '200'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: '1'
    min_freq: '0.01'
    w: 2*3.1416/100
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_1
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: high_cutoff
    interp: '1'
    low_cutoff_freq: low_cutoff
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: high_cutoff
    interp: '1'
    low_cutoff_freq: low_cutoff
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4800'
    max_iter: '4000'
    scale: '0.00020833'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '7639.42'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '1'
    type: fcc
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_sig_source_x_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '1', band_pass_filter_0_0, '0']
- [audio_source_0, '1', fir_filter_xxx_0, '0']
- [audio_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [audio_source_1, '0', qtgui_time_sink_x_1, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_freqdet_cf_0, '0']

metadata:
  file_format: 1
