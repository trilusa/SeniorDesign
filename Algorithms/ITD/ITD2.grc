options:
  parameters:
    author: adrian
    generate_options: qt_gui
    id: fft_test
    output_language: python
    title: FFT Test
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: N_FFT
  id: variable
  parameters:
    value: '512'
  states: {}
- name: N_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-N*N_frames'
    step: '1'
    stop: N*N_frames
    value: '0'
  states: {}
- name: N_delay_tof
  id: variable
  parameters:
    value: int(t_delay_tof/ts)
  states: {state: disabled}
- name: N_delay_tof
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-N*N_frames'
    step: '1'
    stop: N*N_frames
    value: '0'
  states: {}
- name: N_frames
  id: variable
  parameters:
    value: '7'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '100'
  states: {}
- name: f0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: fs/2
    value: '1000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: t
  id: variable
  parameters:
    value: np.linspace(-N*ts/2,N*ts/2,N,endpoint=False)
  states: {}
- name: t_delay
  id: variable
  parameters:
    value: N_delay*ts
  states: {}
- name: t_delay_tof
  id: variable_qtgui_range
  parameters:
    label: d_tof
    start: '-N*2*ts'
    step: ts/10
    stop: N*2*ts
    value: '0'
  states: {state: disabled}
- name: t_delay_tof
  id: variable
  parameters:
    value: 45*ts
  states: {state: disabled}
- name: t_delayed
  id: variable
  parameters:
    value: (t_delay_tof+np.linspace(-N*ts/2,N*ts/2,N,endpoint=False))
  states: {state: disabled}
- name: ts
  id: variable
  parameters:
    value: 1/samp_rate
  states: {}
- name: x
  id: variable
  parameters:
    value: np.sinc(f0*t)
  states: {}
- name: x_delayed
  id: variable
  parameters:
    value: np.sinc(f0*t_delayed)
  states: {state: disabled}
- name: x_w
  id: variable
  parameters:
    value: x*window.blackmanharris(N)
  states: {}
- name: x_w_delayed
  id: variable
  parameters:
    value: x_delayed*window.blackmanharris(N)
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: N_FFT
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(N_delay)
    type: float
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(N_delay_tof)
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: dec
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: N_FFT
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N_FFT
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: N_FFT**-1
    type: float
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: N_FFT**-1
    type: float
    vlen: N_FFT
  states: {state: disabled}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: N_FFT**-1
    type: complex
    vlen: N_FFT
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 1/dec
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_FFT
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_FFT
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N_FFT
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.sin(f0*2.0*np.pi*t)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.tile(x_w,N_frames)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.tile(x_w_delayed,N_frames)
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N_FFT
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N_FFT
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Takes a vector and returns the index of the maximum value"""

          def __init__(self, N=512):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Max idx',   # will show up in GRC
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.N = N

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (np.ones(self.N)*np.argmax(np.fft.fftshift(input_items[0])))-self.N/2
              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N_FFT
    forward: 'True'
    shift: 'False'
    type: float
    window: np.ones(N_FFT)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N_FFT
    forward: 'True'
    shift: 'False'
    type: float
    window: np.ones(N_FFT)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: N_FFT
    forward: 'False'
    shift: 'True'
    type: complex
    window: np.ones(N_FFT)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sample delay"'
    size: '10'
    srate: samp_rate/N_FFT/dec
    type: float
    ylabel: Sample
    ymax: '50'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    label1: '"x(t)"'
    name: '"Input Signal"'
    nconnections: '2'
    vlen: N_FFT
    x_axis_label: '"Time"'
    x_start: '0'
    x_step: ts
    x_units: '"s"'
    y_axis_label: '""'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    label1: '"x(t)"'
    name: '"Magnitude"'
    nconnections: '2'
    vlen: N_FFT
    x_axis_label: '"Frequency"'
    x_start: '-fs/2'
    x_step: fs/N
    x_units: '"Hz"'
    y_axis_label: '""'
    ymax: '.45'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    label1: '"x(t)"'
    name: '"Phase"'
    nconnections: '2'
    vlen: N_FFT
    x_axis_label: '"Frequency"'
    x_start: '-fs/2'
    x_step: fs/N
    x_units: '"Hz"'
    y_axis_label: '"rad"'
    ymax: np.pi
    ymin: '-np.pi'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    label1: '"re"'
    label2: '"im"'
    name: '"Xcorrelation"'
    nconnections: '3'
    vlen: N_FFT
    x_axis_label: '""'
    x_start: '0'
    x_step: '1'
    y_axis_label: '""'
    ymax: '.45'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: N_FFT
    x_start: '0'
    x_step: '1.0'
    ymax: N
    ymin: '0'
  states: {}

connections:
- [audio_source_0, '0', blocks_stream_to_vector_0, '0']
- [audio_source_0, '1', blocks_stream_to_vector_0_1, '0']
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_vector_sink_f_0_0_0, '1']
- [blocks_complex_to_imag_0, '0', qtgui_vector_sink_f_0_0_1, '1']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_vector_sink_f_0_0_1, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_vector_sink_f_0_0_1, '1']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0_0_1, '0']
- [blocks_complex_to_real_1, '0', epy_block_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_vector_sink_f_0_1, '1']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_const_xx_0_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_xx_0_1, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_const_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0, '0', audio_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0, '0', audio_sink_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_one_in_n_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_arg_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_complex_to_real_1, '0']

metadata:
  file_format: 1
